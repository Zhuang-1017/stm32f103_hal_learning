#include "crc16.h"

/* ============================================================================
 *  CRC16_Modbus —— 这段留给你自己填
 * ----------------------------------------------------------------------------
 *  参数（CRC-16/MODBUS 变体，不要改，改了就和标准值对不上）：
 *      多项式   0xA001     （0x8005 的按位反转，因为这里是右移不是左移）
 *      初值     0xFFFF     （不是 0）
 *      输出反转 无
 *      结果异或 0x0000
 *
 *  对每一个字节：
 *      ① crc ^= 本字节                    异或进低 8 位
 *      ② 重复 8 次：
 *           看 crc 的最低位（crc & 1）
 *             为 1  →  crc = (crc >> 1) ^ 0xA001
 *             为 0  →  crc = crc >> 1
 *      ③ 换下一个字节，直到数据用完
 *
 *  为什么是 0xA001 而不是 0x8005：
 *      右移会把最低位挤出去，空洞从最高位补 0，所以要用"镜像"过的多项式
 *      让 x^16 那一项自动绕回来。配 0x8005 写成右移，代码能编译能跑，
 *      结果也"稳定"，但跟任何标准实现对不上——这是 CRC 最典型的静默错误。
 *
 *  验证：CRC16_Modbus("123456789", 9) 必须等于 0x4B37
 *        不是这个数就说明第 ② 步写错了，先别往下测协议。
 * ========================================================================== */
uint16_t CRC16_Modbus(const uint8_t *buf, uint16_t len)
{
    uint16_t crc = 0xFFFF;      /* 初值，注意不是 0 */

    while (len--)
    {
        crc ^= *buf++;          /* ① 本字节异或进低 8 位 */

        for (uint8_t i = 0; i < 8; i++)     /* ② 逐位处理，每字节 8 次 */
        {
            if (crc & 1)                    /* 最低位是 1 */
            {
                crc = (crc >> 1) ^ 0xA001;  /* 右移一位，再把多项式异或回来 */
            }
            else                            /* 最低位是 0 */
            {
                crc = crc >> 1;             /* 只右移，不异或 */
            }
        }
    }

    return crc;
}

/* ============================================================================
 *  自测：用标准输入验证实现，避免"协议不通"时还要怀疑 CRC
 *  "123456789" 这 9 个 ASCII 字符的 CRC-16/MODBUS 是 0x4B37
 * ========================================================================== */
uint8_t CRC16_SelfTest(void)
{
    static const uint8_t check[] = "123456789";

    return (CRC16_Modbus(check, 9u) == 0x4B37u) ? 1u : 0u;
}
